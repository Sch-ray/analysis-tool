# Keil uVision project RF-test.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RF-test +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c include: .\other_library\CC1101;.\other_library\middle;.\other_library\OLED;.\other_library\hack;.\other_library\24C64;.\other_library\Ji2c;.\other_library\RFID
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.c
    ./other_library/CC1101/: CC1101.c CC1101_REG.h
    ./other_library/OLED/: oled.c
    ./other_library/middle/: middle.c
    ./other_library/hack/: charge.c
    ./other_library/24C64/: 24c64.c
    ./other_library/Ji2c/: Ji2c.c
    ./other_library/RFID/: rfid.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:I2C 3.5.0, Device:StdPeriph Drivers:IWDG 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
